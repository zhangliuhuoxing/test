# Keil uVision project EvvGC_FW_0.3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EvvGC_FW_03 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./: STM32F10x.s
  group Source
    ./: stm32f10x_usart.c main.c misc.c system_stm32f10x.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c config.c pins.c utils.c adc.c timers.c i2c.c eeprom.c gyro.c engine.c usart.c
  group Header
    ./: stm32f10x_usart.h misc.h system_stm32f10x.h stm32f10x.h stm32f10x_adc.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_sdio.h stm32f10x_tim.h config.h pins.h utils.h adc.h timers.h eeprom.h i2c.h engine.h gyro.h usart.h
  group misc
    ./: readme.txt
